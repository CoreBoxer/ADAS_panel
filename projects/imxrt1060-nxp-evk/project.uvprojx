# Keil uVision project project.uvprojx, settings and files
target rtthread (6160000::V6.16::ARMCLANG)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.14.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x020000) XRAM(0x20280000,0x040000) XRAM2(0x20200000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __STDC_LIMIT_MACROS, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, RT_USING_LIBC, __FPU_PRESENT=1, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, DATA_SECTION_IS_CACHEABLE=1, XIP_BOOT_HEADER_ENABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, CPU_MIMXRT1062DVL6A, XIP_EXTERNAL_FLASH=1, EVK_MCIMXRM, RT_USING_ARM_LIBC
  c misc: -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: applications;..\..\..\components\net\at\include;..\..\..\components\net\at\at_socket;packages\at_device-latest\inc;packages\at_device-latest\class\esp8266;packages\cJSON-v1.0.2;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\cplusplus;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\MCUX_Config;board\ports;..\libraries\drivers;..\..\..\components\dfs\include;..\..\..\components\finsh;.;..\..\..\include;..\libraries\MIMXRT1060\CMSIS\Include;..\libraries\MIMXRT1060\MIMXRT1060;..\libraries\MIMXRT1060\MIMXRT1060\drivers;..\libraries\peripherals;packages\LVGL-latest\src;packages\LVGL-latest\src\core;packages\LVGL-latest\src\draw;packages\LVGL-latest\src\font;packages\LVGL-latest\src\hal;packages\LVGL-latest\src\misc;packages\LVGL-latest\src\themes;packages\LVGL-latest\src\draw\arm2d;packages\LVGL-latest\src\draw\nxp;packages\LVGL-latest\src\draw\sdl;packages\LVGL-latest\src\draw\stm32_dma2d;packages\LVGL-latest\src\draw\sw;packages\LVGL-latest\src\draw\swm341_dma2d;packages\LVGL-latest\src\draw\nxp\pxp;packages\LVGL-latest\src\draw\nxp\vglite;packages\LVGL-latest\src\layouts\flex;packages\LVGL-latest\src\layouts\grid;packages\LVGL-latest\src\libs\bmp;packages\LVGL-latest\src\libs\ffmpeg;packages\LVGL-latest\src\libs\freetype;packages\LVGL-latest\src\libs\fsdrv;packages\LVGL-latest\src\libs\gif;packages\LVGL-latest\src\libs\png;packages\LVGL-latest\src\libs\qrcode;packages\LVGL-latest\src\libs\rlottie;packages\LVGL-latest\src\libs\sjpg;packages\LVGL-latest\src\others\fragment;packages\LVGL-latest\src\others\gridnav;packages\LVGL-latest\src\others\ime;packages\LVGL-latest\src\others\imgfont;packages\LVGL-latest\src\others\monkey;packages\LVGL-latest\src\others\msg;packages\LVGL-latest\src\others\snapshot;packages\LVGL-latest\src\themes\basic;packages\LVGL-latest\src\themes\default;packages\LVGL-latest\src\themes\mono;packages\LVGL-latest\src\widgets\animimg;packages\LVGL-latest\src\widgets\arc;packages\LVGL-latest\src\widgets\bar;packages\LVGL-latest\src\widgets\btn;packages\LVGL-latest\src\widgets\btnmatrix;packages\LVGL-latest\src\widgets\calendar;packages\LVGL-latest\src\widgets\canvas;packages\LVGL-latest\src\widgets\chart;packages\LVGL-latest\src\widgets\checkbox;packages\LVGL-latest\src\widgets\colorwheel;packages\LVGL-latest\src\widgets\dropdown;packages\LVGL-latest\src\widgets\img;packages\LVGL-latest\src\widgets\imgbtn;packages\LVGL-latest\src\widgets\keyboard;packages\LVGL-latest\src\widgets\label;packages\LVGL-latest\src\widgets\led;packages\LVGL-latest\src\widgets\line;packages\LVGL-latest\src\widgets\list;packages\LVGL-latest\src\widgets\menu;packages\LVGL-latest\src\widgets\meter;packages\LVGL-latest\src\widgets\msgbox;packages\LVGL-latest\src\widgets\objx_templ;packages\LVGL-latest\src\widgets\roller;packages\LVGL-latest\src\widgets\slider;packages\LVGL-latest\src\widgets\span;packages\LVGL-latest\src\widgets\spinbox;packages\LVGL-latest\src\widgets\spinner;packages\LVGL-latest\src\widgets\switch;packages\LVGL-latest\src\widgets\table;packages\LVGL-latest\src\widgets\tabview;packages\LVGL-latest\src\widgets\textarea;packages\LVGL-latest\src\widgets\tileview;packages\LVGL-latest\src\widgets\win;applications\lvgl;packages\LVGL-latest\env_support\rt-thread;applications\lvgl\squareline\ui;packages\mymqtt-latest\MQTTPacket\src;packages\mymqtt-latest\MQTTClient-C;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc;..\..\..\components\net\netdev\include;..\..\..\components\net\sal\include;..\..\..\components\net\sal\include\socket;..\..\..\components\net\sal\impl;..\..\..\components\net\sal\include\dfs_net;..\..\..\components\net\sal\include\socket\sys_socket;xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT4: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt)--keep=*(.boot_hdr.boot_data)--keep=*(.boot_hdr.dcd_data)--keep=*(.boot_hdr.conf)--entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group Applications
    applications/: main.c
  group AT
    ../../../components/net/at/src/: at_client.c at_cli.c at_utils.c
    ../../../components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/class/esp8266/: at_device_esp8266.c at_socket_esp8266.c
    packages/at_device-latest/samples/: at_sample_esp8266.c
    packages/at_device-latest/src/: at_device.c
  group cJSON
    packages/cJSON-v1.0.2/: cJSON_util.c cJSON.c cJSON_port.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPlusPlus
    ../../../components/libc/cplusplus/: cxx_Semaphore.cpp cxx_crt.cpp cxx_Mutex.cpp cxx_Thread.cpp cxx_crt_init.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c dcd.c pin_mux.c
    board/: board.c
    board/ports/: touchpad.c
    ../libraries/drivers/: drv_gpio.c drv_i2c.c drv_lcd.c drv_uart.c
  group Filesystem
    ../../../components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group Libraries
    ../libraries/MIMXRT1060/MIMXRT1060/arm/: startup_MIMXRT1062.s
    ../libraries/MIMXRT1060/MIMXRT1060/drivers/: fsl_cache.c fsl_clock.c fsl_common.c fsl_common_arm.c fsl_elcdif.c fsl_gpio.c fsl_gt911.c fsl_lpi2c.c fsl_lpuart.c fsl_pxp.c fsl_video_common.c fsl_xbara.c fsl_xbarb.c
    ../libraries/MIMXRT1060/MIMXRT1060/: system_MIMXRT1062.c
  group LVGL
    packages/LVGL-latest/src/widgets/bar/: lv_bar.c
    packages/LVGL-latest/src/font/: lv_font_loader.c lv_font_montserrat_8.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_40.c lv_font_montserrat_16.c lv_font_montserrat_32.c lv_font_montserrat_18.c lv_font_montserrat_28.c lv_font_montserrat_44.c lv_font_montserrat_22.c lv_font_montserrat_36.c lv_font.c lv_font_montserrat_26.c lv_font_montserrat_12_subpx.c lv_font_unscii_16.c lv_font_unscii_8.c lv_font_montserrat_20.c lv_font_montserrat_30.c lv_font_fmt_txt.c lv_font_montserrat_48.c lv_font_montserrat_46.c lv_font_montserrat_10.c lv_font_montserrat_28_compressed.c lv_font_montserrat_34.c lv_font_montserrat_42.c lv_font_montserrat_38.c lv_font_montserrat_24.c lv_font_simsun_16_cjk.c
    packages/LVGL-latest/src/misc/: lv_mem.c lv_async.c lv_malloc_builtin.c lv_area.c lv_style.c lv_log.c lv_printf.c lv_templ.c lv_math.c lv_txt.c lv_gc.c lv_memcpy_builtin.c lv_color.c lv_anim_timeline.c lv_txt_ap.c lv_tlsf.c lv_anim.c lv_utils.c lv_lru.c lv_style_gen.c lv_bidi.c lv_timer.c lv_fs.c lv_ll.c
    packages/LVGL-latest/src/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-latest/src/widgets/led/: lv_led.c
    packages/LVGL-latest/src/core/: lv_obj_scroll.c lv_group.c lv_indev.c lv_obj_style.c lv_indev_scroll.c lv_obj_pos.c lv_disp.c lv_obj.c lv_event.c lv_obj_class.c lv_obj_style_gen.c lv_obj_tree.c lv_obj_draw.c lv_refr.c lv_theme.c
    packages/LVGL-latest/src/libs/bmp/: lv_bmp.c
    packages/LVGL-latest/src/draw/nxp/vglite/: lv_draw_vglite_blend.c lv_gpu_nxp_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_rect.c
    packages/LVGL-latest/src/libs/freetype/: lv_freetype.c
    packages/LVGL-latest/src/draw/sdl/: lv_draw_sdl_label.c lv_draw_sdl_mask.c lv_draw_sdl_img.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_rect.c lv_draw_sdl_layer.c lv_draw_sdl_polygon.c lv_draw_sdl_texture_cache.c lv_draw_sdl.c lv_draw_sdl_stack_blur.c lv_draw_sdl_utils.c lv_draw_sdl_line.c lv_draw_sdl_arc.c
    packages/LVGL-latest/src/widgets/calendar/: lv_calendar.c lv_calendar_header_dropdown.c lv_calendar_header_arrow.c
    packages/LVGL-latest/src/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-latest/src/draw/nxp/pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_draw_pxp_blend.c
    packages/LVGL-latest/src/draw/sw/: lv_draw_sw_letter.c lv_draw_sw_img.c lv_draw_sw_polygon.c lv_draw_sw_blend.c lv_draw_sw_arc.c lv_draw_sw_dither.c lv_draw_sw_line.c lv_draw_sw_rect.c lv_draw_sw_gradient.c lv_draw_sw.c lv_draw_sw_transform.c lv_draw_sw_layer.c
    packages/LVGL-latest/src/widgets/list/: lv_list.c
    packages/LVGL-latest/src/themes/default/: lv_theme_default.c
    packages/LVGL-latest/src/layouts/flex/: lv_flex.c
    packages/LVGL-latest/src/libs/fsdrv/: lv_fs_stdio.c lv_fs_fatfs.c lv_fs_posix.c lv_fs_win32.c
    packages/LVGL-latest/src/themes/mono/: lv_theme_mono.c
    packages/LVGL-latest/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-latest/src/hal/: lv_hal_tick.c lv_hal_disp.c lv_hal_indev.c
    packages/LVGL-latest/src/layouts/grid/: lv_grid.c
    packages/LVGL-latest/src/draw/: lv_draw_line.c lv_draw_label.c lv_draw_mask.c lv_draw_transform.c lv_draw_img.c lv_img_cache.c lv_img_buf.c lv_draw_layer.c lv_draw_triangle.c lv_draw_rect.c lv_draw_arc.c lv_img_decoder.c lv_draw.c
    packages/LVGL-latest/src/widgets/canvas/: lv_canvas.c
    packages/LVGL-latest/src/widgets/meter/: lv_meter.c
    packages/LVGL-latest/src/widgets/chart/: lv_chart.c
    packages/LVGL-latest/src/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-latest/src/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-latest/src/others/imgfont/: lv_imgfont.c
    packages/LVGL-latest/src/widgets/dropdown/: lv_dropdown.c
    packages/LVGL-latest/src/widgets/objx_templ/: lv_objx_templ.c
    packages/LVGL-latest/src/libs/png/: lv_png.c lodepng.c
    packages/LVGL-latest/src/widgets/btnmatrix/: lv_btnmatrix.c
    packages/LVGL-latest/src/widgets/tileview/: lv_tileview.c
    packages/LVGL-latest/src/widgets/slider/: lv_slider.c
    packages/LVGL-latest/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-latest/src/others/gridnav/: lv_gridnav.c
    packages/LVGL-latest/src/widgets/checkbox/: lv_checkbox.c
    packages/LVGL-latest/src/widgets/roller/: lv_roller.c
    packages/LVGL-latest/src/widgets/arc/: lv_arc.c
    packages/LVGL-latest/src/widgets/switch/: lv_switch.c
    packages/LVGL-latest/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-latest/src/libs/rlottie/: lv_rlottie.c
    packages/LVGL-latest/src/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-latest/src/widgets/animimg/: lv_animimg.c
    packages/LVGL-latest/src/widgets/win/: lv_win.c
    packages/LVGL-latest/src/others/ime/: lv_ime_pinyin.c
    packages/LVGL-latest/src/others/snapshot/: lv_snapshot.c
    packages/LVGL-latest/src/widgets/btn/: lv_btn.c
    packages/LVGL-latest/src/widgets/line/: lv_line.c
    packages/LVGL-latest/src/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-latest/src/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-latest/src/widgets/menu/: lv_menu.c
    packages/LVGL-latest/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-latest/src/others/monkey/: lv_monkey.c
    packages/LVGL-latest/src/widgets/img/: lv_img.c
    packages/LVGL-latest/src/widgets/table/: lv_table.c
    packages/LVGL-latest/src/libs/sjpg/: tjpgd.c lv_sjpg.c
    packages/LVGL-latest/src/widgets/span/: lv_span.c
    packages/LVGL-latest/src/themes/basic/: lv_theme_basic.c
    packages/LVGL-latest/src/widgets/label/: lv_label.c
    packages/LVGL-latest/src/widgets/tabview/: lv_tabview.c
    packages/LVGL-latest/src/widgets/spinner/: lv_spinner.c
    packages/LVGL-latest/src/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-latest/src/others/msg/: lv_msg.c
    packages/LVGL-latest/src/widgets/textarea/: lv_textarea.c
    packages/LVGL-latest/src/draw/nxp/: lv_gpu_nxp.c
  group LVGL-port
    applications/lvgl/: lv_port_disp.c lv_port_indev.c
    packages/LVGL-latest/env_support/rt-thread/: lv_rt_thread_port.c
  group LVGL-SquareLine
    applications/lvgl/squareline/ui/: ui_img_jinguang_png.c lv_ui_entry.c ui_img_p_png.c ui_img_right1_png.c ui_img_zhizhen1_png.c ui_img_biao2_png.c ui_img_yuanguang_png.c ui_img_underside_png.c ui_img_left1_png.c ui_img_wendu_png.c ui_img_rightleft1_png.c ui_img_indicator_ver_png.c ui_helpers.c ui_img_zhizhen2_png.c ui_img_dianchi_png.c ui_img_jiantou_png.c ui_events.c ui_img_jiyouyali_png.c ui.c ui_img_biao1_png.c ui_img_jiayou_png.c ui_img_rightleft2_png.c
  group my-mqtt
    packages/mymqtt-latest/MQTTPacket/src/: MQTTPacket.c MQTTSubscribeServer.c MQTTSerializePublish.c MQTTUnsubscribeServer.c MQTTFormat.c MQTTDeserializePublish.c MQTTConnectClient.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c MQTTConnectServer.c
    packages/mymqtt-latest/samples/: mqtt_sample.c
    packages/mymqtt-latest/MQTTClient-C/: mqtt_client.c
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_at.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group xip
    xip/: evkbmimxrt1060_flexspi_nor_config.c fsl_flexspi_nor_boot.c
